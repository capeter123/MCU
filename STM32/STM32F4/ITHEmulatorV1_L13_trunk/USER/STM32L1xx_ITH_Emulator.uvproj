# Keil uVision project STM32L1xx_ITH_Emulator.uvproj, settings and files
target STM32L1xx_ITH_Emulator (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L1xx_ITH_Emulator +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32L1xx_MD
  c include: ..\USER;..\FWLIB\inc;..\FWLIB\src;..\CMSIS;.\RTWLibFiles;.\STM32L1xx_Discovery_Driver;.\engine_throttle_ert_rtw
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../CMSIS/: system_stm32l1xx.c
  group USER
    ./: main.c stm32l1xx_it.c stm32l1xx_conf.h Typedefs.h Model_ert_rtw.c
  group DRIVER
    ./STM32L1xx_Discovery_Driver/: stm32l_discovery_lcd.c stm32l_discovery_spi.c TIMx_PWM_Capture.c stm32l_discovery_DAC.c
  group STARTUP
    ../CMSIS/Startup/: startup_stm32l1xx_md.s
  group ITH_Model_Logic
    ./engine_throttle_ert_rtw/: engine_throttle.c engine_throttle_data.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
