# Keil uVision project STM32F407_EGR_Emulator.uvprojx, settings and files
target STM32F407_EGR_Emulator Configuration (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_EGR_Emulator +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx
  c misc: --C99
  c include: ..\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Src\power_BLDC_EGR_ert_rtw; ..\Src\RTWLibFiles; ..\Drivers\Bsp\STM32F4-Discovery; ..\Src\CCP; ..\Src\EGR_CAN_Emu_Model
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../Src/: tim.c main.c gpio.c stm32f4xx_hal_msp.c spi.c dma.c stm32f4xx_it.c can.c EGR_BLL_Interface.c queue.c CCP_CAN_Interface.c Task_Scheduler.c
    ../Inc/: stm32f4xx_hal_conf.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c
  group Application/Model/EGR_BLDC
    ../Src/power_BLDC_EGR_ert_rtw/: HallDecoder_wrapper.c HallEncoder_wrapper.c power_BLDC_EGR.c power_BLDC_EGR_data.c remf_wrapper.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Application/CCP
    ../Src/CCP/: CCP.C
